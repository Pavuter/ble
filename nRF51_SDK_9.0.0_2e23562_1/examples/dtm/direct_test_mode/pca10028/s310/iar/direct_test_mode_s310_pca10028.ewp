# IAR project direct_test_mode_s310_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; S310; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\softdevice\s310\headers; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: direct_test_mode_s310_pca10028.hex
  ILINK.IlinkOutputFile: direct_test_mode_s310_pca10028.out
  ILINK.IlinkIcfFile: direct_test_mode_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
