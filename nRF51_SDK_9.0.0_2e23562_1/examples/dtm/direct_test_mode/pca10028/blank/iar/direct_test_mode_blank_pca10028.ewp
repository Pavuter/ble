# IAR project direct_test_mode_blank_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  OBJCOPY.OOCOutputFile: direct_test_mode_blank_pca10028.hex
  ILINK.IlinkOutputFile: direct_test_mode_blank_pca10028.out
  ILINK.IlinkIcfFile: direct_test_mode_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
