# IAR project ble_app_uart_s110_pca10028.ewp, settings and files
configuration nrf51422_xxac_s110 (ARM)
  General.OGChipSelectEditMenu: nRF51822-QFAC NordicSemi nRF51822-QFAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10028; S110; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0; BSP_UART_SUPPORT; ENABLE_DEBUG_LOG_SUPPORT
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\softdevice\s110\headers; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\drivers_nrf\pstorage; $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\peripheral\rtc\config; ..\..\..\user; ..\..\..\..\..\..\components\_general_lib\include; ..\..\..\..\..\..\components\ble\ble_radio_notification; ..\..\..\..\..\..\components\drivers_nrf\ble_flash; ..\..\..\..\..\..\components\_general_lib\node; ..\..\..\..\..\..\components\_general_lib; ..\..\..\..\..\..\components\_general_lib\queue
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10028; S110; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0
  OBJCOPY.OOCOutputFile: ble_app_uart_s110_pca10028.hex
  ILINK.IlinkOutputFile: ble_app_uart_s110_pca10028.out
  ILINK.IlinkIcfFile: ble_app_uart_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group _general_lib
    ../../../../../../components/_general_lib/common/: key_handler.c led_handler.c queue_mgr.c TaskMgr.c
  group _general_lib/data_manager
    ../../../user/: data_manager.c
  group _general_lib/queue
    ../../../../../../components/_general_lib/queue/: queue.c
  group Application
    ../../../user/: app_calendar.c app_protocol.c app_timing.c
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
    ../../../user/: bsp_flash.c bsp_gpio_ble.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/drivers_nrf/ble_flash/: ble_flash.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../../components/ble/ble_radio_notification/: ble_radio_notification.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c nrf_drv_clock.h
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group protocol
    ../../../user/: ptl_lowlayer.c ptl_midlayer.c
